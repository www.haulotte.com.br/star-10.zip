Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:39:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:39:42 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{0321EE3E-E372-48AA-90A3-8735BB71889F}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:39:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:39:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:39:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Star 26 J, Construction_Aerial-Equipment_Haulotte_Star-26-J_US:Star 26 J:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Red, Metal - Haulotte - White, Metal - Haulotte - Grey, Metal - Haulotte - Yellow
Type - Autre(Type) - Catégorie: Equipement spécialisé; Energy: Electrical; Machine Weight: 2677 kg (6400 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Star-26-J_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Optimum agility in the most congested areas Electric motors with AC technology for smooth and progressive driving 0 cm rear offset and best turning radius on the market Vertical pendulum allowing an offset of 3 m Minimum maintenance and downtime Maintenance-free asynchronous motorization Haulotte Activ'Screen (on-board diagnostics) Centralized battery filling in less than 1 min Enhanced durability New very high strength composite material covers 3 times the service life of parts and components Smart transport Unique forklift system integrated into the chassis Slope climbing up to 25% to climb truck ramps; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Star 26 J; Nom du type: Star 26 J; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/star-10; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Driveable at Full Height up to: 8 m (26 ft 1 in); Drive Speed: 0,6-5 km/h (0,4-3.1 mph); Gradeability: 25%; Ground Clearance: 10 cm (4 in); Height - Stowed: 1,99 m (6 ft 6 in); Horizontal Outreach: 3 m (9 ft 10 in); Jib Length: 1,5 m (4 ft 11 in); Length: 2,7 m (8 ft 10 in); Lift Capacity: #N/A; Max Ground Pressure of Wheel on Paved Ground: 16,82 daN/cm²; Platform Height: 8 m (26ft 1 in); Platform Rotation: N/A; Platform Size: 0,78 x 0.98 m (2 ft 7 in x 3 ft 3 in); Tailswing: 0 cm (4 in); Tilt: 3°; Tires: non marking tires 16 x 5 x 10,5; Turnable Rotation: 345°; Turning Radius - Inside: 0,45 m (1 ft 6 in); Turning Radius - Outside: 1,88 m (6 ft 2 in); Up and Over Clearance: #N/A; Vertical Jib Rotation Angle: 130° (+70°/-60°); Wheelbase: 1,2 m (3 ft 11 in); Width: 1 m (3 ft 3 in); Working Height: 10 m (32ft 1 in)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Star 26 J
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Star-26-J_US: Star 26 J; Famille et type: Construction_Aerial-Equipment_Haulotte_Star-26-J_US: Star 26 J; H: 6.83 m; ID du type: Construction_Aerial-Equipment_Haulotte_Star-26-J_US: Star 26 J; R: 0 deg; Type: Construction_Aerial-Equipment_Haulotte_Star-26-J_US: Star 26 J
Construction - Arm Rotation Angle: -45 deg; Maximum Boom Articulation Point Height: 6.83 m; Reach Diagram: no; Turnable Rotation: 0 deg; Turning Radius: no; Working Area: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 30.6794 m2; Volume: 3.37821 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
